# Keil uVision project balance-car.uvprojx, settings and files
target balance-car (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: balance-car +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --no-multibyte-chars
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../User/Hardware/OLED;../User/System/Delay;../User/System/I2C;../User/Hardware/MPU6050;../User/Hardware/MOTOR;../User/Hardware/PWM;../User/Hardware/ENCODER;../User/Hardware/SENSOR;../User/Hardware/SERIAL;../User/Application/PID
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Hardware
    ../User/Hardware/OLED/: OLED.c OLED_Data.c
    ../User/Hardware/MPU6050/: MPU6050.c inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../User/Hardware/PWM/: PWM.c
    ../User/Hardware/MOTOR/: Motor.c
    ../User/Hardware/ENCODER/: Encoder.c
    ../User/Hardware/SENSOR/: HC_SR04.c
    ../User/Hardware/SERIAL/: Serial_DMA.c
  group System
    ../User/System/Delay/: Delay.c
    ../User/System/I2C/: IIC.c
  group User/Application
    ../User/Application/PID/: PID.c
software components: CMSIS:CORE 4.3.0
